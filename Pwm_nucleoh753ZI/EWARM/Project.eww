<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\Pwm_nucleoh753ZI.ewp</path>
  </project>
  <batchBuild />
</workspace>
